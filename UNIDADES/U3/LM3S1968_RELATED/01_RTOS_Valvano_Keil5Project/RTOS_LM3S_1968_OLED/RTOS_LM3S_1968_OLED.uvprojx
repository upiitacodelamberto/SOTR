# Keil uVision project RTOS_LM3S_1968_OLED.uvprojx, settings and files
target RTOS_LM3S_1968_OLED (5060020::V5.06 (build 20)::ARMCC)
  device: LM3S1968 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS_LM3S_1968_OLED
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./RTE/Device/LM3S1968/: osasm.s os.c user.c
  group driverlib
    ./RTE/Device/LM3S1968/: cpu.c interrupt.c sysctl.c gpio.c Output.c rit128x96x4.c ssi.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
