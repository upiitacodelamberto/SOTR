# Keil uVision project RTOS_LM3S_1968_blocking_semaphore_limbuf.uvprojx, settings and files
target RTOS_blocking_semaphores (5060020::V5.06 (build 20)::ARMCC)
  device: LM3S1968 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS_LM3S_1968_blocking_semaphore_limbuf
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./RTE/Device/LM3S1968/: os.c user.c osasm.s
  group driverlib
    ./RTE/Device/LM3S1968/: cpu.c gpio.c interrupt.c Output.c rit128x96x4.c ssi.c sysctl.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
